# Keil uVision project usart1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: usart1
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c include: ..\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: startup_stm32f051.s
    ../src/: main.c sw_gpio.c sw_rcc.c sw_interrupt.c sw_uart.c
